<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CPU0\CPU0.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CPU1\CPU1.ewp</path>
    </project>
    <batchBuild />
</workspace>
